# Keil uVision project assignment1.uvproj, settings and files
target Target 1 (MCS-51)
  device: see Microchip Atmel Wireless & uC
  output: assignment1
  c flags: Optimize=8 SizeSpeed=1
