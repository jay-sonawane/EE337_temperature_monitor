ORG 0H
MOV 60H, #04H
CLR PSW.5
CLR C
MOV R0, #41H; ADDRESS BIT
MOV R1, #61H; ADRESS BIT INPUT
MOV R2, 60H
MOV R6, 60H
MOV R7, 60H
MOV R5, #0H
MOV R4, #0H
MOV R3, 60H
loop2:
MOV R6, 60H
loop1: MOV A, @R1
MOV @R0, A
INC R0
MOV A, R1
ADD A, R3
MOV R1, A
INC R4
DJNZ R6, loop1
INC R5
MOV R1, #61H
MOV R0, #41H
MOV A, R1
ADD A, R5
MOV R1, A
MOV A, R0
ADD A, R4
MOV R0, A
DJNZ R7, loop2

MOV R3, 60H
looptotal: MOV A, R2
ADD A, 60H
MOV R2, A
DJNZ R3, looptotal

MOV R1, #61H
MOV R0, #41H


loopmain: 
MOV A, @R0
SUBB A, @R1
JNZ LAB
INC R1
INC R0
DJNZ R2, loopmain
SETB PSW.5
LJMP here

LAB: CLR PSW.5
	
here: SJMP here
END
