ORG 0H
LJMP MAIN
ORG 100H

MAIN:	

HERE1: 
MOV C, P1.0
JNC elsepart
MOV C, P1.1
JNC elsepart2

HERELARGE:

SETB P1.4
SETB P1.6

ACALL LOOP1S
CLR P1.4
ACALL LOOP1S
CLR P1.6
ACALL LOOP1S
ACALL LOOP1S

LJMP HERELARGE

elsepart:
MOV C, P1.1
JNC NONE

CLR P1.4

heresmall1:
SETB P1.6
ACALL LOOP1S
ACALL LOOP1S
CLR P1.6
ACALL LOOP1S
ACALL LOOP1S

ljmp heresmall1

elsepart2: 
CLR P1.6

heresmall2:

SETB P1.4
ACALL LOOP1S
CLR P1.4
ACALL LOOP1S
ACALL LOOP1S
ACALL LOOP1S

LJMP heresmall2

NONE:
herenone:

CLR P1.4
CLR P1.6

LJMP herenone 
LJMP HERE1

LOOP1S: MOV R6,#28H
LOOP: ACALL DELAY
      DJNZ R6,LOOP
      LJMP final
DELAY: MOV TMOD,#00000001B 
       MOV TH0,#03CH
       MOV TL0,#0B0H 
       SETB TR0 
HERE: JNB TF0,HERE 
      CLR TR0 
      CLR TF0 
      RET  
      final: RET 

END